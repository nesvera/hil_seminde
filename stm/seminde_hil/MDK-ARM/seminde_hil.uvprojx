# Keil uVision project seminde_hil.uvprojx, settings and files
target seminde_hil (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F103R8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: seminde_hil
  c flags: Optim=4 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F103xB
  c misc: --C99
  c include: ../Inc;../Drivers/STM32F1xx_HAL_Driver/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F1xx/Include;../Drivers/CMSIS/Include;..\Src\library;..\Src\matlab_code
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  link misc: --diag_suppress=L6329
  group Drivers/STM32F1xx_HAL_Driver
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_pwr.c stm32f1xx_hal_tim.c stm32f1xx_hal_dma.c stm32f1xx_hal_uart.c stm32f1xx_hal_cortex.c stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_rcc.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal.c stm32f1xx_hal_gpio.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_flash.c
  group Drivers/CMSIS
    ../Src/: system_stm32f1xx.c
  group Application/User
    ../Src/: stm32f1xx_it.c main.c stm32f1xx_hal_msp.c
    ../Src/library/: hil_lib.c hil_lib.h
    ../Src/matlab_code/: defines.txt ert_main.c modelsources.txt rtwtypes.h sistema.c sistema.h sistema_data.c sistema_private.h sistema_types.h
  group Application/MDK-ARM
    ./: startup_stm32f103xb.s
software components: CMSIS:CORE 5.0.2, Compiler:I/O:STDIN 1.2.0, Compiler:I/O:STDOUT 1.2.0
